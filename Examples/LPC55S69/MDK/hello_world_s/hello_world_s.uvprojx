# Keil uVision project hello_world_s.uvprojx, settings and files
target hello_world_s debug (6120000::V6.12::.\ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.11.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: hello_world_s.axf
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=4
  c define: DEBUG CPU_LPC55S69JBD100_cm33_core0
  c include: ..
  asm define: DEBUG CPU_LPC55S69JBD100_cm33_core0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\hello_world_s.sct
  link misc: --remove --import-cmse-lib-out="./Output/hello_world_cmse.lib"
  group source
    ./: hello_world_s.c hello_world_s.sct
  group trustzone
    ./: tzm_config.c tzm_config.h veneer_table.c tzm_config_mpc.c tzm_config_ppc.c tzm_config_sau.c
    ../: mem_layout.h veneer_table.h
  group doc
    ../: readme.txt
target hello_world_s release (6120000::V6.12::.\ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.11.0.0
  cpu: as above
  output: hello_world_s.axf
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=4
  c define: NDEBUG CPU_LPC55S69JBD100_cm33_core0
  c include: ..
  asm define: CPU_LPC55S69JBD100_cm33_core0 NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\hello_world_s.sct
  link misc: as above
software components: CMSIS:CORE 5.1.1, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.1, Device:SDK Drivers:flexcomm 2.0.0, Device:SDK Drivers:gpio 2.1.3, Device:SDK Drivers:i2c 2.0.3, Device:SDK Drivers:iocon 2.0.0, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.0, Device:SDK Drivers:spi 2.0.3, Device:SDK Drivers:usart 2.0.3, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.0.0
