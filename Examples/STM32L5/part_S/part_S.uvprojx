# Keil uVision project part_S.uvprojx, settings and files
target Debug (6120000::V6.12::.\ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.9-dev4
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x30000000,0x00030000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: part_S
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: ../
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x18000
  scatter file: .\ftl_gen\scatter.sct
  group Source Group 1
    ./: main_s.c
    ../ftl_gen/: SystemIsolation_Config.c
  group Documentation
    ../: Abstract.txt
software components: CMSIS:CORE 5.1.2, Board Support:Drivers:BUS 1.0.0, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:I/O 1.0.0, Board Support:Drivers:IDD 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube HAL:ADC 0.4.0, Device:STM32Cube HAL:Common 0.4.0, Device:STM32Cube HAL:Cortex 0.4.0, Device:STM32Cube HAL:DMA 0.4.0, Device:STM32Cube HAL:EXTI 0.4.0, Device:STM32Cube HAL:Flash 0.4.0, Device:STM32Cube HAL:GPIO 0.4.0, Device:STM32Cube HAL:GTZC 0.4.0, Device:STM32Cube HAL:I2C 0.4.0, Device:STM32Cube HAL:PWR 0.4.0, Device:STM32Cube HAL:RCC 0.4.0, Device:STM32Cube HAL:UART 0.4.0, Device:Startup 1.0.0
