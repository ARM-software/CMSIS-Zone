LR_CODE_NS 0x8040000 0x20000 {
  ER_CODE_NS 0x8040000 0x20000 {
  	* (RESET,+FIRST)
    * (InRoot$$Sections)
    .ANY (+RO, +XO)
  }
  RW_DATA_NS 0x20018000 0x18000 {
    .ANY (+RW +ZI)
  }
}
