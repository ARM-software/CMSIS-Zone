# Keil uVision project blinky_ns.uvprojx, settings and files
target Debug (6120000::V6.12::.\ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.9-dev4
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x30000000,0x00030000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: blinky_ns.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: ../
  memory RVCT4: ROM 0x8040000 size 0x20000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20018000 size 0x18000
  memory RVCT10: RAM 0x30000000 size 0x30000
  scatter file: .\blinky_ns.sct
  group Source Group 1
    ./: main_ns.c blinky_ns.sct
    ../: mem_layout.h
  group CMSE Library
    ../blinky_s/Output/: blinky_s_CMSE_Lib.o
    ../: Secure_Functions.h
  group Documentation
    ../: Abstract.txt
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
