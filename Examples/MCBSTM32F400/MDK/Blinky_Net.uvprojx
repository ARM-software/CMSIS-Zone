# Keil uVision project Blinky_Net.uvprojx, settings and files
target Debug (6120000::V6.12::.\ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0-dev7
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky_Net
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000 ETH_PHY_NUM=1
  c include: .
  asm define: MPU_LOAD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\scatter.sct
  group Source
    ./: main.c main.h app.c BSD.c LED.c ADC.c ETH.c Timer.c faults.c mputable.c mputable.h svc_user.c scatter.sct
  group Documentation
    ./: Abstract.txt
target Release (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0-dev7
  cpu: as above
  output: Blinky_Net
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000
  c include: .
  asm define: MPU_LOAD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\scatter.sct
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.4.0, Compiler:Event Recorder 1.4.0, Board Support:A/D Converter 2.0.0, Board Support:Buttons 2.0.0, Board Support:LED 2.0.0, Network:CORE 7.10.10, Network:CORE 7.10.10, Network:Interface:ETH 7.10.10, Network:Socket:BSD 7.10.10, Network:Socket:TCP 7.10.10, Network:Socket:UDP 7.10.10, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:ST802RT1 6.2.0, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:ADC 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:IWDG 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SRAM 1.7.4, Device:Startup 2.6.2
