# Keil uVision project nsApp.uvprojx, settings and files
target SAML11_ns (6120000::V6.12::.\ARMCLANG)
  device: ATSAML11E16A Microchip
  pack: Keil.SAML11_DFP.1.0.83
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) IROM2(0x00400000,0x800) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ELITTLE
  output: nsApp
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x7c00 size 0x400
  memory RVCT5: ROM 0x8000 size 0x8000
  memory RVCT10: RAM 0x20002000 size 0x2000
  scatter file: ..\..\Zone\ftl_gen\scatter_ns.sct
  group Non-secure Code
    ./: main_ns.c
  group CMSE Library
    ../sApp/Objects/: sApp_CMSE_Lib.o
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
