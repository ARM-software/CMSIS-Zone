# Keil uVision project NonSecure.uvprojx, settings and files
target Nonsecure (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: Nonsecure +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG_PORT=UART1_NS
  c include: .\;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\scatter_ns.sct
  group User
    ./: main_ns.c xom2_func.c xom2_func.h xom3_func.c xom3_func.h scatter_ns.sct
  group Library
    ../Secure/Objects/: Secure_CMSE_Lib.o
software components: CMSIS:CORE 5.2.0, Device:Startup 0.00.001, Device:StdDriver:GPIO 0.00.001
