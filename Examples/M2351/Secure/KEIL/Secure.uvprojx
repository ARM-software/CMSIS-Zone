# Keil uVision project Secure.uvprojx, settings and files
target Secure (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: Secure
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=2
  c define: DEBUG_PORT=UART0
  c misc: -mfloat-abi=soft -Wno-documentation -Wno-reserved-id-macro
  c include: ..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\ftl_gen
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: ..\ftl_gen\scatter.sct
  link misc: --import-cmse-lib-out ..\lib\nsclib_Secure.o
  group User
    ../: main.c xom0_func.c xom1_func.c
    ../../ftl_gen/: partition.h
software components: CMSIS:CORE 5.2.0, Device:Startup 0.00.001, Device:StdDriver:CLK 0.00.001, Device:StdDriver:GPIO 0.00.001
